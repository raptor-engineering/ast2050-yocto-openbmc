# ttyS1 is UART1, connected to on-board console debug port
SERIAL_CONSOLES = "38400;ttyS1"
