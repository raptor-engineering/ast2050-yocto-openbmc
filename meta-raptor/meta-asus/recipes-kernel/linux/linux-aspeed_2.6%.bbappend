LINUX_VERSION_EXTENSION = "-asus"

COMPATIBLE_MACHINE = "asus"

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://defconfig \
           "
